# Keil uVision project sample.uvprojx, settings and files
target Target 1 ()
  device: STM32F103C8
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c
